Commit message: deleted files

File: spot-arm/Assets/Robots/Spot-Arm/ikpy/robot.urdf (robot description, URDF)
Before this commit: robot spot_arm, 8 links, 7 joints
Joints:
- joint gripper_joint: origin xyz=-0.86859 0.043915 -0.029 rpy=0 0 0 -> xyz=0 0.043915 -0.029 rpy=0 0 0
